# Keil uVision project stm32f103ve.uvprojx, settings and files
target stm32f103ve (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103ve +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\startup;..\library\inc;..\user;..\driver\led;..\driver\systick;..\driver\usart;..\driver\mpu6050;..\driver\BaseTim;..\driver\PwmOutput;..\test;..\control;..\control\filter;..\test\waveform;..\driver\led;..\driver\bsp_key;..\driver\usart_mpu;..\driver\usart_hmi;..\driver\usart_hmi\hmi
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group doc
    ../: readme.md
  group startup
    ../startup/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group library
    ../library/src/: misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c
  group driver
    ../driver/systick/: bsp_systick.c
    ../driver/usart/: bsp_usart.c
    ../driver/BaseTim/: bsp_BaseTim.c
    ../driver/PwmOutput/: bsp_pwm_output.c
    ../driver/led/: bsp_led.c
    ../driver/bsp_key/: bsp_key.c
    ../driver/usart_mpu/: bsp_usart2.c usart_mpu.c
    ../driver/usart_hmi/: bsp_usart_hmi.c
    ../driver/usart_hmi/hmi/: HMI_Base_Fun.c
  group user
    ../user/: stm32f10x_conf.h stm32f10x_main.c stm32f10x_it.c
  group test
    ../test/: test.c
    ../test/waveform/: data_scope.c
  group Control
    ../control/: bsp_control.c motor.c Motor_PID.c
    ../control/filter/: ahrs.c
